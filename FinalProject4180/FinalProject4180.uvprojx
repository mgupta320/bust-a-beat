# Keil uVision project FinalProject4180.uvprojx, settings and files
target FinalProject4180 (6070000::V6.7::.\ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: CPUTYPE("Cortex-M3")
  output: FinalProject4180
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: DEVICE_FLASH=1 DEVICE_PORTINOUT=1 DEVICE_CAN=1 MBED_RAM1_SIZE=0x8000 TARGET_LPC176X TARGET_LPC1768 DEVICE_DEBUG_AWARENESS=1 DEVICE_SPISLAVE=1 DEVICE_RESET_REASON=1 TARGET_MBED_LPC1768 TARGET_LIKE_MBED TARGET_NXP DEVICE_USBDEVICE=1 DEVICE_EMAC=1 TARGET_CORTEX DEVICE_SERIAL=1 DEVICE_SEMIHOST=1 MULADDC_CANNOT_USE_R7 MBED_RAM_SIZE=0x8000 TARGET_CORTEX_M __CORTEX_M3 DEVICE_ANALOGOUT=1 MBED_RAM_START=0x10000000 DEVICE_ANALOGIN=1 DEVICE_SERIAL_FC=1 DEVICE_LOCALFILESYSTEM=1 ARM_MATH_CM3 DEVICE_I2C=1 __ASSERT_MSG TARGET_RELEASE DEVICE_ETHERNET=1 MBED_TRAP_ERRORS_ENABLED=1 TARGET_LPCTarget TARGET_NAME=LPC1768 MBED_MINIMAL_PRINTF DEVICE_SPI=1 TOOLCHAIN_ARM DEVICE_USTICKER=1 DEVICE_MPU=1 DEVICE_PWMOUT=1 DEVICE_WATCHDOG=1 DEVICE_I2CSLAVE=1 MBED_RAM1_START=0x2007c000 MBED_BUILD_TIMESTAMP=1650998073.382217 TARGET_NXP_EMAC TOOLCHAIN_ARM_STD DEVICE_SLEEP=1 DEVICE_PORTIN=1 MBED_ROM_START=0x0 DEVICE_PORTOUT=1 MBED_ROM_SIZE=0x80000 TOOLCHAIN_ARMC6 __MBED_CMSIS_RTOS_CM DEVICE_INTERRUPTIN=1 DEVICE_STDIO_MESSAGES=1 __CMSIS_RTOS TARGET_LIKE_CORTEX_M3 __MBED__=1 TARGET_M3 DEVICE_RTC=1
  c misc: -fno-c++-static-destructors -mthumb --target=arm-arm-none-eabi -fshort-wchar -Wno-reserved-user-defined-literal -Wno-armcc-pragma-anon-unions -Wno-armcc-pragma-push-pop -c -fno-rtti -mcpu=cortex-m3 -Wno-deprecated-register -fshort-enums -fdata-sections -fno-exceptions -include mbed_config.h
  c include: ;/usr/src/mbed-sdk;4DGL-uLCD-SE;PinDetect;SDFileSystem;SDFileSystem/FATFileSystem;SDFileSystem/FATFileSystem/ChaN;mbed;mbed-rtos;mbed-rtos/rtos;mbed-rtos/rtx/TARGET_CORTEX_M;mbed/TARGET_LPC1768;mbed/TARGET_LPC1768/TARGET_NXP;mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X;mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768;mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/device;mbed/drivers;mbed/hal;mbed/platform;wave_player
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__CORTEX_M3,-DARM_MATH_CM3,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  link misc: --predefine="-DMBED_RAM1_SIZE=0x8000" --legacyalign --any_contingency --predefine="-DMBED_BOOT_STACK_SIZE=4096" --keep=os_cb_sections --cpu=Cortex-M3 --inline --predefine="-DXIP_ENABLE=0" --predefine="-DMBED_RAM_SIZE=0x8000" --predefine="-DMBED_RAM1_START=0x2007c000" --predefine="-DMBED_RAM_START=0x10000000" --predefine="-DMBED_ROM_SIZE=0x80000" --show_full_path --predefine="-DMBED_ROM_START=0x0"
  group 4DGL-uLCD-SE
    4DGL-uLCD-SE/: uLCD_4DGL.h uLCD_4DGL_Graphics.cpp uLCD_4DGL_main.cpp uLCD_4DGL_Media.cpp uLCD_4DGL_Text.cpp
  group FinalProject4180
    ./: main.cpp mbed_config.h mpr121.cpp mpr121.h Speaker.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o can_api.o cmsis_nvic.o ethernet_api.o gpio_api.o gpio_irq_api.o i2c_api.o mbed.ar mbed_board.o pinmap.o port_api.o pwmout_api.o retarget.o rtc_api.o serial_api.o sleep.o spi_api.o startup_LPC17xx.o sys.o system_LPC17xx.o us_ticker.o
    mbed/TARGET_LPC1768/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_stats.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/device/: cmsis.h cmsis_nvic.h LPC17xx.h system_LPC17xx.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768/: device.h PinNames.h reserved_pins.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/: gpio_object.h objects.h PeripheralNames.h PortNames.h
    mbed/: mbed.h
    mbed/TARGET_LPC1768/TARGET_NXP/: mbed_rtx.h
  group mbed-rtos
    mbed-rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h HAL_CM.c os_tcb.h rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Mutex.c rt_Mutex.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf.h RTX_Conf_CM.c
    mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM/: HAL_CM3.c SVC_Table.s
    mbed-rtos/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
  group PinDetect
    PinDetect/: ChangeLog.h example.h PinDetect.h
  group SDFileSystem
    SDFileSystem/FATFileSystem/ChaN/: ccsbcs.cpp diskio.cpp diskio.h ff.cpp ff.h ffconf.h integer.h
    SDFileSystem/FATFileSystem/: FATDirHandle.cpp FATDirHandle.h FATFileHandle.cpp FATFileHandle.h FATFileSystem.cpp FATFileSystem.h MemFileSystem.h
    SDFileSystem/: SDFileSystem.cpp SDFileSystem.h
  group wave_player
    wave_player/: wave_player.cpp wave_player.h
